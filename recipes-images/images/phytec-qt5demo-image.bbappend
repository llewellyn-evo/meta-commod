

IMAGE_INSTALL_append = " bridge-utils pps-tools ptpd net-tools dune chrony gpsd monit screen opkg socat erlang erlang-sasl erlang-stdlib erlang-kernel erlang-erts erlang-crypto"
