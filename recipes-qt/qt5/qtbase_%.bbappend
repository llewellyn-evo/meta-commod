FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0015-Check-glibc-version-for-renameat2-statx-on-non-boots.patch"
